# Keil uVision project BNO086_MotionDash.uvprojx, settings and files
target BNO086_MotionDash (6220000::V6.22::ARMCLANG)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BNO086_MotionDash +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/Include;../Middlewares/FreeRTOS/include;../Middlewares/FreeRTOS/portable/GCC/ARM_CM4F;../Drivers/BSP/bno08x;../Drivers/BSP/st7789;../Drivers/BSP/console;../App
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ../Core/Startup/: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c system_stm32f4xx.c
  group Application/User/App
    ../App/: app.cpp IMUManager.cpp DisplayManager.cpp
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_exti.c
  group Drivers/BSP/bno08x
    ../Drivers/BSP/bno08x/: sh2.c sh2_util.c shtp.c sh2_SensorValue.c sh2_hal.c bno08x.cpp
  group Drivers/BSP/st7789
    ../Drivers/BSP/st7789/: st7789.cpp font5x7.c
  group Drivers/BSP/console
    ../Drivers/BSP/console/: uart_console.c
  group Middlewares/FreeRTOS
    ../Middlewares/FreeRTOS/: tasks.c queue.c list.c
    ../Middlewares/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
